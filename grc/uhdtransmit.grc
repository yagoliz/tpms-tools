options:
  parameters:
    generate_options: qt_gui
    id: transmituhd
    output_language: python
    title: UHD  WavFile Transmitter
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 433.92e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '80'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0_0_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/ygglc/Git/tpms-tools/example_signals/fsk_signal_example_renault.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '16000'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '128'
    grid: 'True'
    type: complex
    update_time: '0.05'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_float_to_complex_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_float_to_complex_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_float_to_complex_0_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_wavfile_source_0_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_wavfile_source_0_0_0, '1', blocks_float_to_complex_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
